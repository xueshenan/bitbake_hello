addtask build

addtask clean

addtask configure
